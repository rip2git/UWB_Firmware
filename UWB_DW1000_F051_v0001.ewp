# IAR project UWB_DW1000_F051_v0001.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051K8 ST STM32F051K8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\Libraries\CMSIS\CM0\CoreSupport; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\Libraries\CMSIS\CM0\DeviceSupport\ST\STM32F10x; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\Libraries\CMSIS\CM0\DeviceSupport\ST\STM32F10x\startup; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\Libraries\CMSIS\CM0\Include; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\Libraries\CMSIS\CM0\RTOS; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\Libraries\STM32F0xx_StdPeriph_Driver\inc; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\Libraries\STM32F0xx_StdPeriph_Driver\src; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\decadriver; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\platform; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\mLibs; D:\WORKSPACES\WS_IAR\stm32f051\UWB_DW1000_F051_v0001\UAV
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UWB_DW1000_F051_v0001.srec
  ILINK.IlinkOutputFile: UWB_DW1000_F051_v0001.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group decadriver
    decadriver/: deca_device.c deca_device_api.h deca_irqhandler.c deca_irqhandler.h deca_param_types.h deca_params_init.c deca_regs.h deca_types.h deca_version.h
  group Libraries/CMSIS/CM0/CoreSupport
    Libraries/CMSIS/CM0/CoreSupport/: core_cm0.h
  group Libraries/CMSIS/CM0/DeviceSupport/ST/STM32F10x
    Libraries/CMSIS/CM0/DeviceSupport/ST/STM32F10x/: stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group Libraries/CMSIS/CM0/DeviceSupport/ST/STM32F10x/startup
    Libraries/CMSIS/CM0/DeviceSupport/ST/STM32F10x/startup/: startup_stm32f051.s
  group Libraries/CMSIS/CM0/Include
    Libraries/CMSIS/CM0/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group Libraries/CMSIS/CM0/RTOS
    Libraries/CMSIS/CM0/RTOS/: cmsis_os.h
  group Libraries/STM32F0xx_StdPeriph_Driver/inc
    Libraries/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group Libraries/STM32F0xx_StdPeriph_Driver/src
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group mLibs
    mLibs/: CheckSum.c CheckSum.h mBaseTimer.c mBaseTimer.h mUSART.c mUSART.h Random.c Random.h USARTHandler.c USARTHandler.h UserPack.c UserPack.h
  group platform
    platform/: deca_mutex.c deca_sleep.c deca_sleep.h deca_spi.c deca_spi.h port.c port.h stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h
  group UAV
    UAV/: MACFrame.h Ranging.c Ranging.h SWM1000.c SWM1000.h Token.c Token.h Transceiver.c Transceiver.h
