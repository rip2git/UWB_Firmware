<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\UWB_DW1000_F051_v0001.ewp</path>
    </project>
    <batchBuild />
</workspace>
